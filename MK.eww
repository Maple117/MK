<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8l_5043.ewp</path>
    </project>
    <batchBuild />
</workspace>
